<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\..\Programma luci\Luci.ewp</path>
    </project>
    <batchBuild />
</workspace>
